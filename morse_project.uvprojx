# Keil uVision project morse_project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL05Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.12.0
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: tsi_v3
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group Source Group 1
    ./: buzzer.c buzzer.h led.c led.h main.c pit.c pit.h tsi.c tsi.h uart0.c uart0.h MKL05Z4.h MMA8451.c MMA8451.h iic.c iic.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
